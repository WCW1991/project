# IAR project CA7000.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F105xC; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: uCOS-II\Source; uCOS-II\Ports; uCOS-II\Config; APP; APP\Task; APP\Task\Func; BSP; BSP\Driver; BSP\STM32F1xx_HAL_Driver; BSP\STM32F1xx_HAL_Driver\Cfg; BSP\STM32F1xx_HAL_Driver\Inc; BSP\STM32F1xx_HAL_Driver\ST
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CA7000.hex
  ILINK.IlinkOutputFile: 主板f103ve.out
  ILINK.IlinkIcfFile: APP\CA7000.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: app.c app_vect_v5.c ca7000.c ca7000.h CA7000.icf
  group APP/Task
    APP/Task/: Task_Get_Key.c Task_GUI.c Task_Polling.c Task_RefreshScreen.c Task_Status_Indicator.c Task_Time_Display.c
  group APP/Task/Func
    APP/Task/Func/: Bujiantongji.c CheckRecord.c Common.c Config.c Describe.c EnterMenu.c Fault_Display.c Fault_List.c Input_Value.c MainBianChen.c ModifyAddr.c Password.c PrinterSet.c Protocol_Bus.c pyinput.c Record.c Register.c Sampling.c SetThreshold.c SetTime.c Standy_Display.c
  group BSP
    BSP/: Driver.c font.c
  group BSP/Driver
    BSP/Driver/: buzzer.c DS1302.c Key.c LED.c Print.c SG19264.c Usart.c w25x40.c
  group BSP/FWLib
    BSP/STM32F1xx_HAL_Driver/: CPU_init.c
  group BSP/FWLib/Cfg
    BSP/STM32F1xx_HAL_Driver/Cfg/: bsp_periph.c stm32f1xx_hal_conf.h stm32f1xx_hal_msp.c
  group BSP/FWLib/src
    BSP/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_usb.c
  group BSP/FWLib/ST
    BSP/STM32F1xx_HAL_Driver/ST/: system_stm32f1xx.c
  group uCOS-II/Config
    uCOS-II/Config/: includes.h os_cfg.h
  group uCOS-II/Ports
    uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/Source
    uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
